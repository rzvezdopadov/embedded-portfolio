# Keil uVision project SysUprTestUU(STM32).uvprojx, settings and files
target System (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SysUprTestUU(STM32) +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Inc;.\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./Src/: rammap.c rcc.c setting.c flash.c main.c delay.c debug.c criticalinterrupt.c addr.c ints.c leds.c sr.c svbp.c termo_i2c.c uim.c volt.c pulsegen.c volt_adc.c spi.c uart_485.c uart_pc.c uart_pcb.c taskmanager.c modbus.c uart_pc_protocol.c leds_alm.c leds_debug.c
software components: CMSIS:CORE 5.3.0, Device:Startup 2.6.3
